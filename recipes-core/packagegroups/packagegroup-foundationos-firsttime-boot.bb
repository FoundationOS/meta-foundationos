DESCRIPTION ="" 
LICENSE = "None"

inherit packagegroup

# Packages
RDEPENDS_${PN} += "\
	firsttime-boot \
"
